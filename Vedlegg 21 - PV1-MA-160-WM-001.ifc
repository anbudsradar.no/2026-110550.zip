Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverAddonView, ConceptDesignBIM_2010], ExchangeRequirement[Architecture], Option [ExcludedObjects: BlockReference, CurtainWallLayout, Door, WindowAssembly, EntRef, MassElem, MassGroup, MvBlockRef, Railing, Roof, RoofSlab, Slab, , Space, Stair, Member, Wall, Window, Zone, ColumnGrid]
File name: C:\Users\elsf\Desktop\_Hauglifjell VBA\Modeller til leveranse rev03_22_05_2026\PV1-MA-160-WM-001.ifc
Time: 2026-05-21T10:47:09
Author: elsf
Written by: ODA SDAI 24.6
Made in: Build

# IfcProject, 001
LongName: PV1-MA-160-WM-001
ADT_Pset_DISPLAY_SET - ACA_DISPLAY_CONFIG_ON_EXPORT: Standard; ACA_DISPLAY_SET_ON_EXPORT: Model

# IfcBuilding, PV1-MA-160-WM-001
ElevationOfRefHeight: 0 m; ElevationOfTerrain: 0 m
Pset_BuildingCommon - IsPermanentID: no; SprinklerProtection: no; SprinklerProtectionAutomatic: no; GrossPlannedArea: 0 m2; NumberOfStoreys: 0; IsLandmarked: no
Pset_BuildingUse - VacancyRateInCategoryNow: 0; VacancyRateInCategoryFuture: 0
Pset_BuildingWaterStorage - WaterStorageRatePerPerson: 0 m3; OneDayPotableWater: 0 m3; OneDayEssentialWater: 0 m3; OneDayCoolingTowerMakeupWater: 0 m3; OneDayProcessOrProductionWater: 0 m3
ePset_BuildingEnergyTarget - BuildingEnergyTargetValue: 0

# IfcBuildingElementProxy (58)
In: PV1-MA-160-WM-001
Name | Entreprise | Omrade | Delomrade | Fag | MMI | MMI_Dato | MMI_Utfort | MMI_Kontrollert | MMI_Godkjent | RIVA_Objekt | RIVA_Dimensjon | RIVA_Styrkeklasse | RIVA_Materiale

BUILDINGELEMENTPROXY(4) | E1 | 16 | 160 | W | 300 | 2026.04.10 | ESF | TKS | APH | PE100 rør SDR17 | 500 | SDR117 | PE100
BUILDINGELEMENTPROXY(6) | E1 | 16 | 160 | W | 300 | 2026.04.10 | ESF | TKS | APH | PE100 rør SDR17 | 500 | SDR117 | PE100
BUILDINGELEMENTPROXY(8) | E1 | 16 | 160 | W | 300 | 2026.04.10 | ESF | TKS | APH | PE100 rør SDR17 | 500 | SDR117 | PE100
BUILDINGELEMENTPROXY(10) | E1 | 16 | 160 | W | 300 | 2026.04.10 | ESF | TKS | APH | PE100 rør SDR17 | 500 | SDR117 | PE100
BUILDINGELEMENTPROXY(12) | E1 | 16 | 160 | W | 300 | 2026.04.10 | ESF | TKS | APH | PE100 rør SDR17 | 500 | SDR117 | PE100
BUILDINGELEMENTPROXY(14) | E1 | 16 | 160 | W | 300 | 2026.04.10 | ESF | TKS | APH | PE100 rør SDR17 | 500 | SDR117 | PE100
BUILDINGELEMENTPROXY(16) | E1 | 16 | 160 | W | 300 | 2026.04.10 | ESF | TKS | APH | PE100 rør SDR17 | 500 | SDR117 | PE100
BUILDINGELEMENTPROXY(18) | E1 | 16 | 160 | W | 300 | 2026.04.10 | ESF | TKS | APH | PE100 rør SDR17 | 500 | SDR117 | PE100
BUILDINGELEMENTPROXY(20) | E1 | 16 | 160 | W | 300 | 2026.04.10 | ESF | TKS | APH | PE100 rør SDR17 | 500 | SDR117 | PE100
BUILDINGELEMENTPROXY(22) | E1 | 16 | 160 | W | 300 | 2026.04.10 | ESF | TKS | APH | PE100 rør SDR17 | 500 | SDR117 | PE100
BUILDINGELEMENTPROXY(24) | E1 | 16 | 160 | W | 300 | 2026.04.10 | ESF | TKS | APH | PE100 rør SDR17 | 500 | SDR117 | PE100
BUILDINGELEMENTPROXY(26) | E1 | 16 | 160 | W | 300 | 2026.04.10 | ESF | TKS | APH | PE100 rør SDR17 | 500 | SDR117 | PE100
BUILDINGELEMENTPROXY(28) | E1 | 16 | 160 | W | 300 | 2026.04.10 | ESF | TKS | APH | PE100 rør SDR17 | 500 | SDR117 | PE100
BUILDINGELEMENTPROXY(30) | E1 | 16 | 160 | W | 300 | 2026.04.10 | ESF | TKS | APH | PE100 rør SDR17 | 500 | SDR117 | PE100
BUILDINGELEMENTPROXY(32) | E1 | 16 | 160 | W | 300 | 2026.04.10 | ESF | TKS | APH | PE100 rør SDR17 | 500 | SDR117 | PE100
BUILDINGELEMENTPROXY(34) | E1 | 16 | 160 | W | 300 | 2026.04.10 | ESF | TKS | APH | PE100 rør SDR17 | 500 | SDR117 | PE100
BUILDINGELEMENTPROXY(36) | E1 | 16 | 160 | W | 300 | 2026.04.10 | ESF | TKS | APH | PE100 rør SDR17 | 500 | SDR117 | PE100
BUILDINGELEMENTPROXY(38) | E1 | 16 | 160 | W | 300 | 2026.04.10 | ESF | TKS | APH | PE100 rør SDR17 | 500 | SDR117 | PE100
BUILDINGELEMENTPROXY(40) | E1 | 16 | 160 | W | 300 | 2026.04.10 | ESF | TKS | APH | PE100 rør SDR17 | 500 | SDR117 | PE100
BUILDINGELEMENTPROXY(42) | E1 | 16 | 160 | W | 300 | 2026.04.10 | ESF | TKS | APH | PE100 rør SDR17 | 500 | SDR117 | PE100
BUILDINGELEMENTPROXY(44) | E1 | 16 | 160 | W | 300 | 2026.04.10 | ESF | TKS | APH | PE100 rør SDR17 | 500 | SDR117 | PE100
BUILDINGELEMENTPROXY(46) | E1 | 16 | 160 | W | 300 | 2026.04.10 | ESF | TKS | APH | PE100 rør SDR17 | 500 | SDR117 | PE100
BUILDINGELEMENTPROXY(48) | E1 | 16 | 160 | W | 300 | 2026.04.10 | ESF | TKS | APH | PE100 rør SDR17 | 500 | SDR117 | PE100
BUILDINGELEMENTPROXY(50) | E1 | 16 | 160 | W | 300 | 2026.04.10 | ESF | TKS | APH | PE100 rør SDR17 | 500 | SDR117 | PE100
BUILDINGELEMENTPROXY(52) | E1 | 16 | 160 | W | 300 | 2026.04.10 | ESF | TKS | APH | PE100 rør SDR17 | 500 | SDR117 | PE100
BUILDINGELEMENTPROXY(54) | E1 | 16 | 160 | W | 300 | 2026.04.10 | ESF | TKS | APH | PE100 rør SDR17 | 500 | SDR117 | PE100
BUILDINGELEMENTPROXY(56) | E1 | 16 | 160 | W | 300 | 2026.04.10 | ESF | TKS | APH | PE100 rør SDR17 | 500 | SDR117 | PE100
BUILDINGELEMENTPROXY(58) | E1 | 16 | 160 | W | 300 | 2026.04.10 | ESF | TKS | APH | PE100 rør SDR17 | 500 | SDR117 | PE100
BUILDINGELEMENTPROXY(60) | E1 | 16 | 160 | W | 300 | 2026.04.10 | ESF | TKS | APH | PE100 rør SDR17 | 500 | SDR117 | PE100
BUILDINGELEMENTPROXY(62) | E1 | 16 | 160 | W | 300 | 2026.04.10 | ESF | TKS | APH | PE100 rør SDR17 | 500 | SDR117 | PE100
BUILDINGELEMENTPROXY(64) | E1 | 16 | 160 | W | 300 | 2026.04.10 | ESF | TKS | APH | PE100 rør SDR17 | 500 | SDR117 | PE100
BUILDINGELEMENTPROXY(66) | E1 | 16 | 160 | W | 300 | 2026.04.10 | ESF | TKS | APH | PE100 rør SDR17 | 500 | SDR117 | PE100
BUILDINGELEMENTPROXY(68) | E1 | 16 | 160 | W | 300 | 2026.04.10 | ESF | TKS | APH | PE100 rør SDR17 | 500 | SDR117 | PE100
BUILDINGELEMENTPROXY(70) | E1 | 16 | 160 | W | 300 | 2026.04.10 | ESF | TKS | APH | PE100 rør SDR17 | 500 | SDR117 | PE100
BUILDINGELEMENTPROXY(72) | E1 | 16 | 160 | W | 300 | 2026.04.10 | ESF | TKS | APH | PE100 rør SDR17 | 500 | SDR117 | PE100
BUILDINGELEMENTPROXY(74) | E1 | 16 | 160 | W | 300 | 2026.04.10 | ESF | TKS | APH | PE100 rør SDR17 | 500 | SDR117 | PE100
BUILDINGELEMENTPROXY(76) | E1 | 16 | 160 | W | 300 | 2026.04.10 | ESF | TKS | APH | PE100 rør SDR17 | 500 | SDR117 | PE100
BUILDINGELEMENTPROXY(78) | E1 | 16 | 160 | W | 300 | 2026.04.10 | ESF | TKS | APH | PE100 rør SDR17 | 500 | SDR117 | PE100
BUILDINGELEMENTPROXY(80) | E1 | 16 | 160 | W | 300 | 2026.04.10 | ESF | TKS | APH | PE100 rør SDR17 | 500 | SDR117 | PE100
BUILDINGELEMENTPROXY(82) | E1 | 16 | 160 | W | 300 | 2026.04.10 | ESF | TKS | APH | PE100 rør SDR17 | 500 | SDR117 | PE100
BUILDINGELEMENTPROXY(84) | E1 | 16 | 160 | W | 300 | 2026.04.10 | ESF | TKS | APH | PE100 rør SDR17 | 500 | SDR117 | PE100
BUILDINGELEMENTPROXY(86) | E1 | 16 | 160 | W | 300 | 2026.04.10 | ESF | TKS | APH | PE100 rør SDR17 | 500 | SDR117 | PE100
BUILDINGELEMENTPROXY(88) | E1 | 16 | 160 | W | 300 | 2026.04.10 | ESF | TKS | APH | PE100 rør SDR17 | 500 | SDR117 | PE100
BUILDINGELEMENTPROXY(90) | E1 | 16 | 160 | W | 300 | 2026.04.10 | ESF | TKS | APH | PE100 rør SDR17 | 500 | SDR117 | PE100
BUILDINGELEMENTPROXY(92) | E1 | 16 | 160 | W | 300 | 2026.04.10 | ESF | TKS | APH | PE100 rør SDR17 | 500 | SDR117 | PE100
BUILDINGELEMENTPROXY(94) | E1 | 16 | 160 | W | 300 | 2026.04.10 | ESF | TKS | APH | PE100 rør SDR17 | 500 | SDR117 | PE100
BUILDINGELEMENTPROXY(96) | E1 | 16 | 160 | W | 300 | 2026.04.10 | ESF | TKS | APH | PE100 rør SDR17 | 500 | SDR117 | PE100
BUILDINGELEMENTPROXY(98) | E1 | 16 | 160 | W | 300 | 2026.04.10 | ESF | TKS | APH | PE100 rør SDR17 | 500 | SDR117 | PE100
BUILDINGELEMENTPROXY(100) | E1 | 16 | 160 | W | 300 | 2026.04.10 | ESF | TKS | APH | PE100 rør SDR17 | 500 | SDR117 | PE100
BUILDINGELEMENTPROXY(102) | E1 | 16 | 160 | W | 300 | 2026.04.10 | ESF | TKS | APH | PE100 rør SDR17 | 500 | SDR117 | PE100
BUILDINGELEMENTPROXY(104) | E1 | 16 | 160 | W | 300 | 2026.04.10 | ESF | TKS | APH | PE100 rør SDR17 | 500 | SDR117 | PE100
BUILDINGELEMENTPROXY(106) | E1 | 16 | 160 | W | 300 | 2026.04.10 | ESF | TKS | APH | PE100 rør SDR17 | 500 | SDR117 | PE100
BUILDINGELEMENTPROXY(108) | E1 | 16 | 160 | W | 300 | 2026.04.10 | ESF | TKS | APH | PE100 rør SDR17 | 500 | SDR117 | PE100
BUILDINGELEMENTPROXY(110) | E1 | 16 | 160 | W | 300 | 2026.04.10 | ESF | TKS | APH | PE100 rør SDR17 | 500 | SDR117 | PE100
BUILDINGELEMENTPROXY(112) | E1 | 16 | 160 | W | 300 | 2026.04.10 | ESF | TKS | APH | PE100 rør SDR17 | 500 | SDR117 | PE100
BUILDINGELEMENTPROXY(114) | E1 | 16 | 160 | W | 300 | 2026.04.10 | ESF | TKS | APH | PE100 rør SDR17 | 500 | SDR117 | PE100
BUILDINGELEMENTPROXY(116) | E1 | 16 | 160 | W | 300 | 2026.04.10 | ESF | TKS | APH | PE100 rør SDR17 | 500 | SDR117 | PE100
