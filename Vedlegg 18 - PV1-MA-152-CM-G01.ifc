Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Fjellhall og adkomsttunnel.ifc
Time: 2026-04-09T12:11:02
Author: gmf
Written by: DDS_IFC v3.0
Made in: Gemini Terrain Version 20 x64 build 12/3-2025
Authorization: DDS

# IfcProxy: IfcGeographicElement.NOTDEFINED (2)
ProxyType: PRODUCT; Group: IFC fjellhall og adkomsttunnel.aly
NRVA - Entreprise: E1 - Berg, grunn, bygg og VA; Område: 150; Delområde: 152; Fag: RIGberg; MMI: 375; MMI_Dato: 26.03.2026; MMI_Kontrollert: EMG; MMI_Godkjent: EMG
RIGberg - RIGberg_Kommentar: Fjellhall og adkomsttunnel. Det er modellert med både sprengningsprofil og normalprofil. Spregningsprofil representerer den teoretiske utsprengte overflaten, altså volumet som skal sprenges ut. Normalprofilen viser den ferdige tunnelgeometrien etter bygging. Mellom spregningsprofilet og normalprofilet ligger sonen som det er satt av til bergsikring.
Name | MMI_Utført
Sprengningsprofil | GMF | NRVA - RIGberg_Kommentar: Fjellhall og adkomsttunnel. Det er modellert med både sprengningsprofil og normalprofil. Spregningsprofil representerer den teoretiske utsprengte overflaten, altså volumet som skal sprenges ut. Normalprofilen viser den ferdige tunnelgeometrien etter bygging. Mellom spregningsprofilet og normalprofilet ligger sonen som det er satt av til bergsikring.
Normalprofil | EMG
