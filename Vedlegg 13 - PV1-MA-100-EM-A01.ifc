Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: 2b143afa-2c95-4969-b3f6-2743c52fa253, VersionGUID: 42eda25e-822f-4ae7-8153-c51c2e3c920b, NumberOfSaves: 318], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: NTM]
File name: PV1-MA-100-EM-A01.ifc
Time: 2026-05-21T14:06:32+01:00
Organization: Multiconsult Norge AS
Written by: ODA SDAI 24.12
Made in: Autodesk Revit 25.4.0.32 (ENU) - IFC 25.4.0.27

# IfcProject, 10258651
LongName: Hauglifjell; Phase: Forprosjekt

# IfcSite, Referanseeiendom
LongName: 12345; RefLatitude: 49, 0, 24, 428900; RefLongitude: 10, 7, 59, 338362; RefElevation: 0 mm

# IfcBuilding, Referansebygning
LongName: Referansebygning
Pset_BuildingCommon - BuildingID: 123456; NumberOfStoreys: 2

# IfcBuildingStorey: Level:8mm Head (5)
In: Referansebygning
Pset_AirSideSystemInformation - sets with these values: 2
Name | LongName = Name | Elevation (mm)
Fjellhall Bergsåle | Fjellhall Bergsåle | 111450
Fjellhall Plan U | Fjellhall Plan U | 112050
Fjellhall Innkjøring | Fjellhall Innkjøring | 112930
Fjellhall Plan 1 | Fjellhall Plan 1 | 113150
Fjellhall Plan 2 | Fjellhall Plan 2 | 116700

# IfcBuildingStorey: Level:Nivå 2.5mm (PBP) (7)
In: Referansebygning
Pset_AirSideSystemInformation - sets with these values: 2
Name | LongName = Name | Elevation (mm)
PV1 - Plan U3 | PV1 - Plan U3 | 91200
PV1 - Plan U2 | PV1 - Plan U2 | 93200
PV1 - Plan U1 | PV1 - Plan U1 | 95900
PV1 - Plan 1 | PV1 - Plan 1 | 97200
PV1 - Plan 2 | PV1 - Plan 2 | 102000
PV1 - Plan 3 | PV1 - Plan 3 | 105300
PV1 - Innkjøring Portal | PV1 - Innkjøring Portal | 111700

# IfcBuildingElementProxy: Dummy Mechanical Equipment-kun tekst:Dummy Mechanical Equipment (9)
In: Fjellhall Plan U
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Dummy Mechanical Equipment-kun tekst:Dummy Mechanical Equipment; sets with these values: 2
NRVA - Fag: RIE; MMI_Kontrollert: OLSK; MMI_Utfort: CAH; MMI: 250; Delomrade: 130; Entreprise: E1; Omrade: 130; MMI_Godkjent: APH; MMI_Dato: 24.03.2026
RIE - V_Type: Dummy Mechanical Equipment; V_Referansenivå: Fjellhall Plan U
Mengde - Volum: 0.000774249 m3; Lengde: 500 mm
Name (Dummy Mechanical Equipment-kun tekst:Dummy Mechanical Equipment:...) | V_Installasjonshøyde
4925991 | -1290
4940690 | -790
4940768 | -540
4940776 | -835
4940784 | -670
4940866 | -1170
4941249 | -690
4941550 | -1495
4941558 | -1090

# IfcBuildingElementProxy: Jordingspunkt for armering (Vegg):Jordingspunkt for armering (9)
In: Fjellhall Plan U
Type - Material: <Unnamed>
Classification: 412 Jording for elkraftinstallasjoner (Uniformat)
Pset_BuildingElementProxyCommon - Reference: Jordingspunkt for armering (Vegg):Jordingspunkt for armering; sets with these values: 2
NRVA - Fag: RIE; MMI_Kontrollert: OLSK; MMI_Utfort: CAH; MMI: 250; Delomrade: 152; Entreprise: E1; Omrade: 150; MMI_Godkjent: APH; MMI_Dato: 24.03.2026; Tag: KJC0002
RIE - V_Type: Jordingspunkt for armering; V_Referansenivå: Fjellhall Plan U; V_Installasjonshøyde: 500
ID - Tag: KJC0002
Mengde - Volum: 0.0000215442 m3
Name (Jordingspunkt for armering (Vegg):Jordingspunkt for armering:...)
4786971
4791498
4791897
4791906
4791915
4791954
4791991
4792006
4792017

# IfcBuildingElementProxy: Jordskinne-2:Hovedjordskinne (11)
In: Fjellhall Plan 1
Type - Material: Kanaler
Classification: 412 Jording for elkraftinstallasjoner (Uniformat)
Pset_BuildingElementProxyCommon - Reference: Jordskinne-2:Hovedjordskinne; sets with these values: 2
NRVA - Fag: RIE; MMI_Kontrollert: OLSK; MMI_Utfort: CAH; MMI: 250; Delomrade: 152; Entreprise: E1; MMI_Godkjent: APH; MMI_Dato: 24.03.2026; Tag: KJC0001
RIE - V_Type: Hovedjordskinne; V_Referansenivå: Fjellhall Plan 1; V_Installasjonshøyde: 128
ID - Tag: KJC0001
Mengde - Volum: 0.0000297919 m3
Name (Jordskinne-2:Hovedjordskinne:...)
4790436
4791633
4791896
4791905
4791914
4791953
4791990
4792005
4792016
4792027
4792283

# IfcBuildingElementProxy: Trekkekum TK2:TK2-500 (2)
In: Fjellhall Plan U
Type - Material: Betong Prefab, Stål - S355
Pset_BuildingElementProxyCommon - Reference: Trekkekum TK2:TK2-500; sets with these values: 2
NRVA - Fag: RIE; MMI_Kontrollert: OLSK; MMI_Utfort: CAH; MMI: 250; Delomrade: 130; Entreprise: E1; Omrade: 130; MMI_Godkjent: APH; MMI_Dato: 24.03.2026
RIE - V_Type: TK2-500; V_Referansenivå: Fjellhall Plan U
Mengde - Volum: 0.424456 m3; Lengde: 1620 mm
Name (Trekkekum TK2:TK2-500:...) | V_Installasjonshøyde
4796972 | -290
4797721 | -1120

# IfcDistributionPort (544)
Description: Flow; FlowDirection: SOURCEANDSINK
Name
Port_4654295_0
Port_4867894_1
Port_4654295_1
Port_4655065_0
Port_4919484_1
Port_4655065_1
Port_4660544_2
Port_4655126_0
Port_4660542_1
Port_4655126_1
Port_4655383_0
Port_4916995_1
Port_4655383_1
Port_4655384_1
Port_4655384_2
Port_4655386_0
Port_4655386_1
Port_4660519_2
Port_4655387_0
Port_4660504_1
Port_4655387_1
Port_4655585_0
Port_4867886_1
Port_4655585_1
Port_4655604_0
Port_4867878_1
Port_4655604_1
Port_4655621_0
Port_4655623_1
Port_4655621_1
Port_4655623_2
Port_4866172_0
Port_4656122_0
Port_4656238_2
Port_4656122_1
Port_4916863_1
Port_4656231_0
Port_4656238_1
Port_4656231_1
Port_4656611_0
Port_4656613_2
Port_4656611_1
Port_4916778_1
Port_4656612_0
Port_4656613_1
Port_4656612_1
Port_4657998_0
Port_4657998_1
Port_4849836_1
Port_4658002_0
Port_4849834_1
Port_4658002_1
Port_4658052_0
Port_4658052_1
Port_4849802_1
Port_4658056_0
Port_4849804_1
Port_4658056_1
Port_4658069_0
Port_4658069_1
Port_4849770_1
Port_4658073_0
Port_4849772_1
Port_4658073_1
Port_4660490_0
Port_4660504_2
Port_4660490_1
Port_4660519_1
Port_4660540_0
Port_4660542_2
Port_4660540_1
Port_4660544_1
Port_4663072_0
Port_4663072_1
Port_4663106_0
Port_4663106_1
Port_4778633_0
Port_4778633_1
Port_4779283_0
Port_4779283_1
Port_4779290_0
Port_4779290_1
Port_4780396_0
Port_4780396_1
Port_4780823_0
Port_4780823_1
Port_4780832_0
Port_4780832_1
Port_4783495_0
Port_4872121_1
Port_4783495_1
Port_4800829_0
Port_4941899_2
Port_4800829_1
Port_4800921_0
Port_4801515_1
Port_4800921_1
Port_4801466_0
Port_4801466_1
Port_4801515_2
Port_4801573_0
Port_4939015_2
Port_4801573_1
Port_4801579_0
Port_4801581_1
Port_4801579_1
Port_4801580_0
Port_4801580_1
Port_4801581_2
Port_4808606_0
Port_4872372_2
Port_4808606_1
Port_4808880_0
Port_4872390_2
Port_4808880_1
Port_4849768_0
Port_4849770_2
Port_4849768_1
Port_4849772_2
Port_4849800_0
Port_4849802_2
Port_4849800_1
Port_4849804_2
Port_4849832_0
Port_4849834_2
Port_4849832_1
Port_4849836_2
Port_4866172_1
Port_4866280_1
Port_4866280_2
Port_4866296_0
Port_4866296_1
Port_4867827_1
Port_4867870_0
Port_4867827_2
Port_4867829_0
Port_4867829_1
Port_4867838_1
Port_4867880_0
Port_4867838_2
Port_4867840_0
Port_4867840_1
Port_4867849_1
Port_4867888_0
Port_4867849_2
Port_4867851_0
Port_4867851_1
Port_4867870_1
Port_4867878_2
Port_4867880_1
Port_4867886_2
Port_4867888_1
Port_4867894_2
Port_4868720_0
Port_4868720_1
Port_4872121_2
Port_4870381_0
Port_4872372_1
Port_4870381_1
Port_4871646_0
Port_4938154_2
Port_4871646_1
Port_4938342_1
Port_4872390_1
Port_4937925_0
Port_4877600_0
Port_4884357_1
Port_4877600_1
Port_4877602_0
Port_4937203_2
Port_4877602_1
Port_4935759_2
Port_4877603_0
Port_4877609_2
Port_4877603_1
Port_4935763_2
Port_4877604_0
Port_4877609_1
Port_4877604_1
Port_4877611_2
Port_4877611_1
Port_4932307_0
Port_4879354_0
Port_4880790_2
Port_4879354_1
Port_4879357_0
Port_4879361_2
Port_4879357_1
Port_4879361_1
Port_4931819_0
Port_4879363_1
Port_4879363_2
Port_4931819_1
Port_4880154_0
Port_4880171_2
Port_4880154_1
Port_4880155_0
Port_4942768_2
Port_4880155_1
Port_4880157_0
Port_4880157_1
Port_4880161_2
Port_4880158_0
Port_4880161_1
Port_4880158_1
Port_4880163_2
Port_4880163_1
Port_4880171_1
Port_4942766_0
Port_4880790_1
Port_4943196_0
Port_4884357_2
Port_4937201_0
Port_4916023_0
Port_4916028_1
Port_4916023_1
Port_4916024_1
Port_4916027_0
Port_4916024_2
Port_4916026_0
Port_4916026_1
Port_4916027_1
Port_4916028_2
Port_4916317_0
Port_4916865_1
Port_4916317_1
Port_4916344_0
Port_4916780_1
Port_4916344_1
Port_4916763_0
Port_4916778_2
Port_4916763_1
Port_4916780_2
Port_4916853_0
Port_4916863_2
Port_4916853_1
Port_4916865_2
Port_4916988_0
Port_4916995_2
Port_4916988_1
Port_4917166_0
Port_4917167_2
Port_4917166_1
Port_4917167_1
Port_4917264_0
Port_4917264_1
Port_4917272_1
Port_4917272_2
Port_4919290_0
Port_4919290_1
Port_4919481_1
Port_4919470_0
Port_4919481_2
Port_4919470_1
Port_4919484_2
Port_4920176_0
Port_4922413_1
Port_4920176_1
Port_4920351_1
Port_4924094_0
Port_4920351_2
Port_4922487_0
Port_4920456_0
Port_4922563_1
Port_4920456_1
Port_4920461_1
Port_4924152_0
Port_4920461_2
Port_4923395_0
Port_4920477_0
Port_4922641_1
Port_4920477_1
Port_4921636_0
Port_4924466_1
Port_4921636_1
Port_4924513_1
Port_4921746_0
Port_4924510_2
Port_4921746_1
Port_4921773_0
Port_4924426_1
Port_4921773_1
Port_4921801_0
Port_4922237_2
Port_4921801_1
Port_4924589_1
Port_4921802_0
Port_4924586_2
Port_4921802_1
Port_4921805_0
Port_4924665_1
Port_4921805_1
Port_4921959_0
Port_4924662_2
Port_4921959_1
Port_4922250_1
Port_4922228_0
Port_4922237_1
Port_4922228_1
Port_4922254_2
Port_4922239_0
Port_4922250_2
Port_4922239_1
Port_4922254_1
Port_4922402_0
Port_4922413_2
Port_4922402_1
Port_4922494_1
Port_4922487_1
Port_4922494_2
Port_4922556_0
Port_4922563_2
Port_4922556_1
Port_4922610_1
Port_4922603_0
Port_4922610_2
Port_4922603_1
Port_4923222_2
Port_4922634_0
Port_4922641_2
Port_4922634_1
Port_4922681_1
Port_4922644_0
Port_4922684_2
Port_4922644_1
Port_4923928_1
Port_4922681_2
Port_4923028_0
Port_4922684_1
Port_4924192_0
Port_4923028_1
Port_4923713_2
Port_4923222_1
Port_4923620_0
Port_4923395_1
Port_4923683_1
Port_4923620_1
Port_4923632_1
Port_4923627_0
Port_4923632_2
Port_4923627_1
Port_4923679_2
Port_4923677_0
Port_4923679_1
Port_4923677_1
Port_4923683_2
Port_4923706_0
Port_4923713_1
Port_4923706_1
Port_4923720_1
Port_4923715_0
Port_4923720_2
Port_4923715_1
Port_4923925_2
Port_4923923_0
Port_4923925_1
Port_4923923_1
Port_4923928_2
Port_4924094_1
Port_4924152_1
Port_4924192_1
Port_4924426_2
Port_4924460_0
Port_4924460_1
Port_4924466_2
Port_4924508_0
Port_4924510_1
Port_4924508_1
Port_4924513_2
Port_4924584_0
Port_4924586_1
Port_4924584_1
Port_4924589_2
Port_4924660_0
Port_4924662_1
Port_4924660_1
Port_4924665_2
Port_4928925_1
Port_4928996_1
Port_4929413_0
Port_4929413_1
Port_4931233_2
Port_4929542_0
Port_4929542_1
Port_4931292_2
Port_4929552_0
Port_4929552_1
Port_4939376_2
Port_4930032_0
Port_4930032_1
Port_4930033_0
Port_4930033_1
Port_4939473_2
Port_4931190_0
Port_4931190_1
Port_4931207_2
Port_4931207_1
Port_4940056_0
Port_4931233_1
Port_4940147_0
Port_4931251_0
Port_4931251_1
Port_4931266_2
Port_4931266_1
Port_4939976_0
Port_4931292_1
Port_4940131_0
Port_4932135_0
Port_4941899_1
Port_4932135_1
Port_4932168_0
Port_4939015_1
Port_4932168_1
Port_4932307_1
Port_4932510_0
Port_4938154_1
Port_4932510_1
Port_4932524_2
Port_4932517_0
Port_4932524_1
Port_4932517_1
Port_4935757_0
Port_4937027_1
Port_4935757_1
Port_4935763_1
Port_4935759_1
Port_4936660_0
Port_4936660_1
Port_4937024_2
Port_4937022_0
Port_4937024_1
Port_4937022_1
Port_4937027_2
Port_4937201_1
Port_4937203_1
Port_4937507_0
Port_4937526_2
Port_4937507_1
Port_4937516_2
Port_4937508_0
Port_4937510_2
Port_4937508_1
Port_4937518_2
Port_4937509_0
Port_4937510_1
Port_4937509_1
Port_4937512_2
Port_4937512_1
Port_4937514_0
Port_4937514_1
Port_4937515_0
Port_4943517_2
Port_4937515_1
Port_4937518_1
Port_4937516_1
Port_4937520_0
Port_4937520_1
Port_4943520_1
Port_4937526_1
Port_4937925_1
Port_4937927_1
Port_4937927_2
Port_4937939_0
Port_4937939_1
Port_4938338_2
Port_4938336_0
Port_4938338_1
Port_4938336_1
Port_4938342_2
Port_4938692_0
Port_4938698_2
Port_4938692_1
Port_4938703_1
Port_4938693_0
Port_4938698_1
Port_4938693_1
Port_4938695_2
Port_4938694_0
Port_4938695_1
Port_4938694_1
Port_4938697_0
Port_4938734_2
Port_4938697_1
Port_4938701_2
Port_4938700_0
Port_4938701_1
Port_4938700_1
Port_4938703_2
Port_4938734_1
Port_4939376_1
Port_4940081_0
Port_4939473_1
Port_4940070_0
Port_4939735_0
Port_4939735_1
Port_4939976_1
Port_4940056_1
Port_4940070_1
Port_4940081_1
Port_4940131_1
Port_4940147_1
Port_4942766_1
Port_4942768_1
Port_4942873_0
Port_4943198_2
Port_4942873_1
Port_4943196_1
Port_4943198_1
Port_4943515_0
Port_4943517_1
Port_4943515_1
Port_4943520_2
Port_5042548_0
Port_5042548_1
Port_5042874_0
Port_5042874_1
Port_5042883_0
Port_5042883_1
Port_5043037_0
Port_5043037_1
Port_5043038_0
Port_5043038_1
Port_5043039_0
Port_5043039_1
Port_5044333_0
Port_5044333_1
Port_5045461_2
Port_5045290_0
Port_5045290_1
Port_5045331_1
Port_5045316_0
Port_5045329_1
Port_5045316_1
Port_5045331_2
Port_5045329_2
Port_5045616_0
Port_5045454_0
Port_5045461_1
Port_5045454_1
Port_5045616_1
Port_5045632_2
Port_5045625_0
Port_5045625_1
Port_5045632_1

# IfcFlowFitting: Conduit Coupling - PVC:Skjøt for PVC rør standard (6)
In: Fjellhall Plan U
Type - Material: <Unnamed>
Classification: 4112 Installasjonskanaler med uttaksbokser (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Conduit Coupling - PVC:Skjøt for PVC rør standard; sets with these values: 2
NRVA - Fag: RIE; MMI_Kontrollert: OLSK; MMI_Utfort: CAH; MMI: 250; Delomrade: 130; Entreprise: E1; Omrade: 130; MMI_Godkjent: APH; MMI_Dato: 24.03.2026
RIE - V_Type: Skjøt for PVC rør standard; V_Referansenivå: Fjellhall Plan U
Name (Conduit Coupling - PVC:Skjøt for PVC rør standard:...) | V_Lengde (mm) | V_Dimensjon | V_Installasjonshøyde
4937203 | 127.316 | 160 mmøx160 mmø | 126
4937526 | 127.316 | 160 mmøx160 mmø | 190
4937927 | 98.8156 | 110 mmøx110 mmø | 248
4938734 | 98.8156 | 110 mmøx110 mmø | 248
4942768 | 127.316 | 160 mmøx160 mmø | 130
4943198 | 127.316 | 160 mmøx160 mmø | 130

# IfcFlowFitting: Conduit Elbow - Plain End - PVC:Bend for PVC standard (104)
In: Fjellhall Plan U
Type - Material: <Unnamed>
Classification: 4112 Installasjonskanaler med uttaksbokser (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Conduit Elbow - Plain End - PVC:Bend for PVC standard; sets with these values: 2
NRVA - Fag: RIE; MMI_Kontrollert: OLSK; MMI_Utfort: CAH; MMI: 250; Entreprise: E1; MMI_Godkjent: APH
RIE - V_Type: Bend for PVC standard; V_Referansenivå: Fjellhall Plan U
Name (Conduit Elbow - Plain End - PVC:Bend for PVC standard:...) | Delomrade | Omrade | MMI_Dato | V_Dimensjon | V_Installasjonshøyde
4655384 | 152 | 150 | 24.03.2026 | 110 mmøx110 mmø | 435
4655623 | 152 | 150 | 24.03.2026 | 110 mmøx110 mmø | 435
4656238 | 152 | 150 | 24.03.2026 | 110 mmøx110 mmø | 435
4656613 | 152 | 150 | 24.03.2026 | 110 mmøx110 mmø | 435
4660504 | 152 | 150 | 24.03.2026 | 110 mmøx110 mmø | 435
4660519 | 152 | 150 | 24.03.2026 | 110 mmøx110 mmø | 435
4660542 | 152 | 150 | 24.03.2026 | 110 mmøx110 mmø | 435
4660544 | 152 | 150 | 24.03.2026 | 110 mmøx110 mmø | 435
4801515 | 130 | 130 | 24.03.2026 | 110 mmøx110 mmø | -786
4801581 | 130 | 130 | 24.03.2026 | 110 mmøx110 mmø | -786
4849770 | 152 | 150 | 24.03.2026 | 110 mmøx110 mmø | 435
4849772 | 152 | 150 | 24.03.2026 | 110 mmøx110 mmø | 435
4849802 | 152 | 150 | 24.03.2026 | 110 mmøx110 mmø | 435
4849804 | 152 | 150 | 24.03.2026 | 110 mmøx110 mmø | 435
4849834 | 152 | 150 | 24.03.2026 | 110 mmøx110 mmø | 435
4849836 | 152 | 150 | 24.03.2026 | 110 mmøx110 mmø | 435
4866280 | 152 | 150 | 24.03.2026 | 110 mmøx110 mmø | 435
4867827 | 152 | 150 | 24.03.2026 | 110 mmøx110 mmø | 435
4867838 | 152 | 150 | 24.03.2026 | 110 mmøx110 mmø | 435
4867849 | 152 | 150 | 24.03.2026 | 110 mmøx110 mmø | 435
4867878 | 152 | 150 | 24.03.2026 | 110 mmøx110 mmø | 435
4867886 | 152 | 150 | 24.03.2026 | 110 mmøx110 mmø | 435
4867894 | 152 | 150 | 24.03.2026 | 110 mmøx110 mmø | 435
4872121 | 152 | 150 | 24.03.2026 | 160 mmøx160 mmø | 190
4872372 | 152 | 150 | 24.03.2026 | 110 mmøx110 mmø | 244
4872390 | 152 | 150 | 24.03.2026 | 110 mmøx110 mmø | 248
4877609 | 130 | 130 | 24.03.2026 | 160 mmøx160 mmø | -254
4877611 | 130 | 130 | 24.03.2026 | 160 mmøx160 mmø | -378
4879361 | 130 | 130 | 24.03.2026 | 160 mmøx160 mmø | -404
4879363 | 130 | 130 | 24.03.2026 | 160 mmøx160 mmø | -574
4880161 | 130 | 130 | 24.03.2026 | 160 mmøx160 mmø | -426
4880163 | 130 | 130 | 24.03.2026 | 160 mmøx160 mmø | -590
4880171 | 152 | 150 | 24.03.2026 | 160 mmøx160 mmø | 130
4880790 | 152 | 150 | 24.03.2026 | 160 mmøx160 mmø | 130
4884357 | 152 | 150 | 24.03.2026 | 160 mmøx160 mmø | 126
4916024 | 152 | 150 | 24.03.2026 | 110 mmøx110 mmø | 435
4916028 | 152 | 150 | 24.03.2026 | 110 mmøx110 mmø | 435
4916778 | 152 | 150 | 24.03.2026 | 110 mmøx110 mmø | 435
4916780 | 152 | 150 | 24.03.2026 | 110 mmøx110 mmø | 435
4916863 | 152 | 150 | 24.03.2026 | 110 mmøx110 mmø | 435
4916865 | 152 | 150 | 24.03.2026 | 110 mmøx110 mmø | 435
4916995 | 152 | 150 | 24.03.2026 | 110 mmøx110 mmø | 435
4917167 | 152 | 150 | 24.03.2026 | 110 mmøx110 mmø | 595
4917272 | 152 | 150 | 24.03.2026 | 110 mmøx110 mmø | 595
4919481 | 152 | 150 | 24.03.2026 | 110 mmøx110 mmø | 595
4919484 | 152 | 150 | 24.03.2026 | 110 mmøx110 mmø | 435
4920351 | 130 | 130 | 24.03.2026 | 110 mmøx110 mmø | 102
4920461 | 130 | 130 | 24.03.2026 | 110 mmøx110 mmø | 102
4922237 | 130 | 130 | 24.03.2026 | 50 mmøx50 mmø | 435
4922250 | 130 | 130 | 24.03.2026 | 50 mmøx50 mmø | 435
4922254 | 130 | 130 | 24.03.2026 | 50 mmøx50 mmø | 435
4922413 | 152 | 150 | 24.03.2026 | 110 mmøx110 mmø | 701
4922494 | 152 | 150 | 24.03.2026 | 110 mmøx110 mmø | 102
4922563 | 152 | 150 | 24.03.2026 | 110 mmøx110 mmø | 541
4922610 | 152 | 150 | 24.03.2026 | 110 mmøx110 mmø | -50
4922641 | 152 | 150 | 24.03.2026 | 110 mmøx110 mmø | 381
4922681 | 152 | 150 | 24.03.2026 | 110 mmøx110 mmø | -201
4922684 | 130 | 130 | 24.03.2026 | 110 mmøx110 mmø | 102
4923222 | 130 | 130 | 24.03.2026 | 110 mmøx110 mmø | -50
4923632 | 130 | 130 | 24.03.2026 | 110 mmøx110 mmø | -50
4923679 | 130 | 130 | 24.03.2026 | 110 mmøx110 mmø | -50
4923683 | 130 | 130 | 24.03.2026 | 110 mmøx110 mmø | 102
4923713 | 130 | 130 | 24.03.2026 | 110 mmøx110 mmø | -201
4923720 | 130 | 130 | 24.03.2026 | 110 mmøx110 mmø | -201
4923925 | 130 | 130 | 24.03.2026 | 110 mmøx110 mmø | -201
4923928 | 130 | 130 | 24.03.2026 | 110 mmøx110 mmø | 102
4924426 | 152 | 150 | 24.03.2026 | 50 mmøx50 mmø | 765
4924466 | 152 | 150 | 24.03.2026 | 50 mmøx50 mmø | 435
4924510 | 130 | 130 | 24.03.2026 | 50 mmøx50 mmø | 765
4924513 | 130 | 130 | 24.03.2026 | 50 mmøx50 mmø | 435
4924586 | 130 | 130 | 24.03.2026 | 50 mmøx50 mmø | 725
4924589 | 130 | 130 | 24.03.2026 | 50 mmøx50 mmø | 435
4924662 | 130 | 130 | 24.03.2026 | 50 mmøx50 mmø | 435
4924665 | 130 | 130 | 24.03.2026 | 50 mmøx50 mmø | 765
4931207 | 130 | 130 | 24.03.2026 | 160 mmøx160 mmø | -378
4931233 | 130 | 130 | 24.03.2026 | 160 mmøx160 mmø | -568
4931266 | 130 | 130 | 24.03.2026 | 160 mmøx160 mmø | -378
4931292 | 130 | 130 | 24.03.2026 | 160 mmøx160 mmø | -568
4932524 | 130 | 130 | 24.03.2026 | 110 mmøx110 mmø | -593
4935759 | 130 | 130 | 24.03.2026 | 160 mmøx160 mmø | 126
4935763 | 130 | 130 | 24.03.2026 | 160 mmøx160 mmø | -101
4937024 | 130 | 130 | 24.03.2026 | 160 mmøx160 mmø | 86
4937027 | 130 | 130 | 24.03.2026 | 160 mmøx160 mmø | -69
4937510 | 130 | 130 | 24.03.2026 | 160 mmøx160 mmø | -248
4937512 | 130 | 130 | 24.03.2026 | 160 mmøx160 mmø | -378
4937516 | 130 | 130 | 24.03.2026 | 160 mmøx160 mmø | 190
4937518 | 130 | 130 | 24.03.2026 | 160 mmøx160 mmø | -96
4938154 | 130 | 130 | 24.03.2026 | 110 mmøx110 mmø | -593
4938338 | 130 | 130 | 24.03.2026 | 110 mmøx110 mmø | 248
4938342 | 130 | 130 | 24.03.2026 | 110 mmøx110 mmø | -563
4938695 | 130 | 130 | 24.03.2026 | 110 mmøx110 mmø | -593
4938698 | 130 | 130 | 24.03.2026 | 110 mmøx110 mmø | -593
4938701 | 130 | 130 | 24.03.2026 | 110 mmøx110 mmø | 248
4938703 | 130 | 130 | 24.03.2026 | 110 mmøx110 mmø | -563
4939015 | 130 | 130 | 24.03.2026 | 110 mmøx110 mmø | -148
4939376 | 130 | 130 | 24.03.2026 | 110 mmøx110 mmø | -403
4939473 | 130 | 130 | 24.03.2026 | 110 mmøx110 mmø | -403
4941899 | 130 | 130 | 24.03.2026 | 110 mmøx110 mmø | -209
4943517 | 130 | 130 | 24.03.2026 | 160 mmøx160 mmø | -67
4943520 | 130 | 130 | 24.03.2026 | 160 mmøx160 mmø | 151
5045329 | 130 | 130 | 21.06.2026 | 110 mmøx110 mmø | -6193
5045331 | 130 | 130 | 21.06.2026 | 110 mmøx110 mmø | -6193
5045461 | 130 | 130 | 21.06.2026 | 110 mmøx110 mmø | -6193
5045632 | 130 | 130 | 21.06.2026 | 110 mmøx110 mmø | -6193

# IfcFlowSegment: Conduit with Fittings:Glatte rør PVC (87)
In: Fjellhall Plan U
Type - PredefinedType: CONDUITSEGMENT
Classification: 4112 Installasjonskanaler med uttaksbokser (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Conduit with Fittings:Glatte rør PVC; sets with these values: 2
Pset_FlowSegmentDuctSegment - sets with these values: 2
NRVA - Fag: RIE; MMI_Kontrollert: OLSK; MMI_Utfort: CAH; MMI: 250; Entreprise: E1; MMI_Godkjent: APH; MMI_Dato: 24.03.2026
RIE - V_Type: Glatte rør PVC; V_Referansenivå: Fjellhall Plan U
Name (Conduit with Fittings:Glatte rør PVC:...) | Length (mm) = V_Lengde (mm) | Delomrade | Omrade | V_Dimensjon | V_Installasjonshøyde
4654295 | 1375.72 | 152 | 150 | 110 mmø | 435
4655065 | 25798.6 | 152 | 150 | 110 mmø | 435
4655126 | 2416.48 | 152 | 150 | 110 mmø | 435
4655383 | 1467.16 | 152 | 150 | 110 mmø | 435
4655386 | 27458.3 | 152 | 150 | 110 mmø | 435
4655387 | 2536.48 | 152 | 150 | 110 mmø | 435
4655585 | 1223.58 | 152 | 150 | 110 mmø | 435
4655604 | 1075.72 | 152 | 150 | 110 mmø | 435
4655621 | 923.582 | 152 | 150 | 110 mmø | 435
4656122 | 21901.7 | 152 | 150 | 110 mmø | 435
4656231 | 719.992 | 152 | 150 | 110 mmø | 435
4656611 | 21708.2 | 152 | 150 | 110 mmø | 435
4656612 | 569.992 | 152 | 150 | 110 mmø | 435
4657998 | 916.6 | 152 | 150 | 110 mmø | 435
4658002 | 3061.04 | 152 | 150 | 110 mmø | 435
4658052 | 1010.29 | 152 | 150 | 110 mmø | 435
4658056 | 2967.35 | 152 | 150 | 110 mmø | 435
4658069 | 1098.09 | 152 | 150 | 110 mmø | 435
4658073 | 2879.56 | 152 | 150 | 110 mmø | 435
4660490 | 1737.09 | 152 | 150 | 110 mmø | 435
4660540 | 1694.66 | 152 | 150 | 110 mmø | 435
4663072 | 5000 | 152 | 150 | 110 mmø | 435
4663106 | 5000 | 152 | 150 | 110 mmø | 435
4800829 | 1942.94 | 130 | 130 | 110 mmø | -209
4800921 | 8983.62 | 130 | 130 | 110 mmø | -786
4801466 | 2157.4 | 130 | 130 | 110 mmø | -786
4801573 | 1933.13 | 130 | 130 | 110 mmø | -148
4801579 | 9009.95 | 130 | 130 | 110 mmø | -786
4801580 | 2283.73 | 130 | 130 | 110 mmø | -786
4849768 | 568.989 | 152 | 150 | 110 mmø | 435
4849800 | 568.989 | 152 | 150 | 110 mmø | 435
4849832 | 568.989 | 152 | 150 | 110 mmø | 435
4866172 | 36694 | 152 | 150 | 110 mmø | 435
4866296 | 12504.9 | 130 | 130 | 110 mmø | 432
4867829 | 12504.9 | 130 | 130 | 110 mmø | 432
4867840 | 12504.9 | 130 | 130 | 110 mmø | 432
4867851 | 12504.9 | 130 | 130 | 110 mmø | 432
4867870 | 36824 | 152 | 150 | 110 mmø | 435
4867880 | 36954 | 152 | 150 | 110 mmø | 435
4867888 | 37084 | 152 | 150 | 110 mmø | 435
4916023 | 1525.72 | 152 | 150 | 110 mmø | 435
4916026 | 12504.9 | 130 | 130 | 110 mmø | 432
4916027 | 37214 | 152 | 150 | 110 mmø | 435
4916317 | 313.582 | 152 | 150 | 110 mmø | 1021
4916344 | 313.582 | 152 | 150 | 110 mmø | 1021
4916763 | 453.013 | 152 | 130 | 110 mmø | 435
4916853 | 661.55 | 152 | 150 | 110 mmø | 435
4916988 | 213.582 | 152 | 150 | 110 mmø | 1021
4917166 | 53.582 | 152 | 150 | 110 mmø | 1181
4917264 | 1438.46 | 152 | 150 | 110 mmø | 595
4919290 | 801.626 | 152 | 150 | 110 mmø | 595
4919470 | 46.3518 | 152 | 150 | 110 mmø | 524
4920176 | 1265.61 | 152 | 150 | 110 mmø | 994
4920456 | 1425.61 | 152 | 150 | 110 mmø | 834
4920477 | 1585.61 | 152 | 150 | 110 mmø | 674
4921636 | 5146.17 | 152 | 150 | 50 mmø | 435
4921746 | 258.462 | 152 | 150 | 50 mmø | 937
4921773 | 258.462 | 152 | 150 | 50 mmø | 937
4921801 | 14.9116 | 152 | 150 | 50 mmø | 435
4921802 | 298.462 | 152 | 150 | 50 mmø | 897
4921805 | 258.462 | 152 | 150 | 50 mmø | 937
4921959 | 6196.93 | 152 | 150 | 50 mmø | 435
4922228 | 137.603 | 152 | 150 | 50 mmø | 435
4922239 | 127.317 | 152 | 150 | 50 mmø | 435
4922402 | 260.402 | 152 | 150 | 110 mmø | 493
4922487 | 9933.71 | 130 | 130 | 110 mmø | 102
4922556 | 248.686 | 152 | 150 | 110 mmø | 333
4922603 | 2971.46 | 130 | 130 | 110 mmø | -50
4922634 | 235.966 | 152 | 150 | 110 mmø | 173
4922644 | 4649.98 | 130 | 130 | 110 mmø | 102
4923028 | 3139.6 | 130 | 130 | 110 mmø | -201
4923395 | 4690.7 | 130 | 130 | 110 mmø | 102
4923620 | 46.3518 | 130 | 130 | 110 mmø | -50
4923627 | 839.544 | 130 | 130 | 110 mmø | -50
4923677 | 94.4242 | 130 | 130 | 110 mmø | 10
4923706 | 490.583 | 130 | 130 | 110 mmø | -201
4923715 | 9.54439 | 130 | 130 | 110 mmø | -201
4923923 | 535.933 | 130 | 130 | 110 mmø | -141
4924094 | 526.475 | 130 | 130 | 110 mmø | 102
4924152 | 346.475 | 130 | 130 | 110 mmø | 102
4924192 | 197.206 | 130 | 130 | 110 mmø | 102
4924460 | 124.563 | 152 | 150 | 50 mmø | 644
4924508 | 124.563 | 152 | 150 | 50 mmø | 644
4924584 | 67.9943 | 152 | 150 | 50 mmø | 604
4924660 | 124.563 | 130 | 130 | 50 mmø | 556
4932135 | 3424.26 | 130 | 130 | 110 mmø | -251
4932168 | 3578.21 | 130 | 130 | 110 mmø | -201

# IfcFlowSegment: Conduit with Fittings:Høyspent (75)
In: Fjellhall Plan U
Type - PredefinedType: CONDUITSEGMENT
Classification: 4112 Installasjonskanaler med uttaksbokser (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Conduit with Fittings:Høyspent; sets with these values: 2
Pset_FlowSegmentDuctSegment - sets with these values: 2
NRVA - Fag: RIE; MMI_Kontrollert: OLSK; MMI_Utfort: CAH; MMI: 250; Entreprise: E1; MMI_Godkjent: APH
RIE - V_Type: Høyspent; V_Referansenivå: Fjellhall Plan U
Name (Conduit with Fittings:Høyspent:...) | Length (mm) = V_Lengde (mm) | Delomrade | Omrade | MMI_Dato | V_Dimensjon | V_Installasjonshøyde
4778633 | 5840 | 152 | 150 | 24.03.2026 | 160 mmø | 200
4779283 | 5920 | 152 | 150 | 24.03.2026 | 160 mmø | 200
4779290 | 6000 | 152 | 150 | 24.03.2026 | 160 mmø | 200
4780396 | 10900 | 152 | 150 | 24.03.2026 | 160 mmø | 200
4780823 | 10920 | 152 | 150 | 24.03.2026 | 160 mmø | 200
4780832 | 10960.7 | 152 | 150 | 24.03.2026 | 160 mmø | 200
4783495 | 994.701 | 152 | 150 | 24.03.2026 | 160 mmø | 190
4808606 | 2178.96 | 152 | 150 | 24.03.2026 | 110 mmø | 244
4808880 | 2016.11 | 152 | 150 | 24.03.2026 | 110 mmø | 248
4868720 | 11131.2 | 152 | 150 | 24.03.2026 | 160 mmø | 190
4870381 | 8180.83 | 152 | 150 | 24.03.2026 | 110 mmø | 244
4871646 | 6012.52 | 130 | 130 | 24.03.2026 | 110 mmø | -563
4877600 | 1101.12 | 152 | 150 | 24.03.2026 | 160 mmø | 126
4877602 | 3210.93 | 130 | 130 | 24.03.2026 | 160 mmø | 126
4877603 | 1989.44 | 130 | 130 | 24.03.2026 | 160 mmø | -192
4877604 | 21.9165 | 130 | 130 | 24.03.2026 | 160 mmø | -316
4879354 | 1028.91 | 152 | 150 | 24.03.2026 | 160 mmø | 130
4879357 | 10594.9 | 130 | 130 | 24.03.2026 | 160 mmø | -328
4880154 | 750.983 | 152 | 150 | 24.03.2026 | 160 mmø | 130
4880155 | 270 | 130 | 130 | 24.03.2026 | 160 mmø | 130
4880157 | 10383.1 | 130 | 130 | 24.03.2026 | 160 mmø | 135
4928925 | 5226.01 | 152 | 150 | 24.03.2026 | 100 mmø | 200
4928996 | 5242.81 | 152 | 150 | 24.03.2026 | 110 mmø | 200
4929413 | 32037.5 | 130 | 130 | 24.03.2026 | 160 mmø | -568
4929542 | 31958.8 | 130 | 130 | 24.03.2026 | 160 mmø | -568
4929552 | 32199.3 | 130 | 130 | 24.03.2026 | 110 mmø | -403
4930032 | 51527.5 | 130 | 130 | 24.03.2026 | 110 mmø | -593
4930033 | 32116.8 | 130 | 130 | 24.03.2026 | 110 mmø | -403
4931190 | 32037.5 | 130 | 130 | 24.03.2026 | 160 mmø | -378
4931251 | 31958.8 | 130 | 130 | 24.03.2026 | 160 mmø | -378
4931819 | 1022.32 | 130 | 130 | 24.03.2026 | 160 mmø | -476
4932307 | 181.525 | 130 | 130 | 24.03.2026 | 160 mmø | -378
4932510 | 446.164 | 130 | 130 | 24.03.2026 | 110 mmø | -593
4932517 | 667.035 | 130 | 130 | 24.03.2026 | 110 mmø | -593
4935757 | 1097.86 | 130 | 130 | 24.03.2026 | 160 mmø | -71
4936660 | 1592.3 | 130 | 130 | 24.03.2026 | 160 mmø | 115
4937022 | 209.774 | 130 | 130 | 24.03.2026 | 160 mmø | 37
4937201 | 11239.5 | 152 | 150 | 24.03.2026 | 160 mmø | 126
4937507 | 3323.7 | 130 | 130 | 24.03.2026 | 160 mmø | 190
4937508 | 1963.28 | 130 | 130 | 24.03.2026 | 160 mmø | -187
4937509 | 186.726 | 130 | 130 | 24.03.2026 | 160 mmø | -310
4937514 | 326.184 | 130 | 130 | 24.03.2026 | 160 mmø | -378
4937515 | 919.582 | 130 | 130 | 24.03.2026 | 160 mmø | -70
4937520 | 1550.03 | 130 | 130 | 24.03.2026 | 160 mmø | 180
4937925 | 8113.95 | 152 | 150 | 24.03.2026 | 110 mmø | 248
4937939 | 1052.98 | 130 | 130 | 24.03.2026 | 110 mmø | 248
4938336 | 1906.67 | 130 | 130 | 24.03.2026 | 110 mmø | 89
4938692 | 6272.44 | 130 | 130 | 24.03.2026 | 110 mmø | -563
4938693 | 269.498 | 130 | 130 | 24.03.2026 | 110 mmø | -593
4938694 | 999.58 | 130 | 130 | 24.03.2026 | 110 mmø | -593
4938697 | 1072.98 | 130 | 130 | 24.03.2026 | 110 mmø | 248
4938700 | 1906.67 | 130 | 130 | 24.03.2026 | 110 mmø | 89
4939735 | 51527.5 | 130 | 130 | 24.03.2026 | 110 mmø | -593
4939976 | 4508.99 | 130 | 130 | 24.03.2026 | 160 mmø | -378
4940056 | 4667.69 | 130 | 130 | 24.03.2026 | 160 mmø | -378
4940070 | 4799.41 | 130 | 130 | 24.03.2026 | 110 mmø | -403
4940081 | 4836.52 | 130 | 130 | 24.03.2026 | 110 mmø | -403
4940131 | 4508.99 | 130 | 130 | 24.03.2026 | 160 mmø | -568
4940147 | 4667.69 | 130 | 130 | 24.03.2026 | 160 mmø | -568
4942766 | 5707.43 | 152 | 150 | 24.03.2026 | 160 mmø | 130
4942873 | 72.6844 | 130 | 130 | 24.03.2026 | 160 mmø | 130
4943196 | 5808.73 | 152 | 150 | 24.03.2026 | 160 mmø | 130
4943515 | 439.611 | 130 | 130 | 24.03.2026 | 160 mmø | -18
5042548 | 1600 | 152 | 150 | 20.05.2026 | 160 mmø | 110
5042874 | 1600 | 152 | 150 | 20.05.2026 | 160 mmø | 110
5042883 | 1600 | 152 | 150 | 20.05.2026 | 160 mmø | 110
5043037 | 1600 | 152 | 150 | 20.05.2026 | 160 mmø | 110
5043038 | 1600 | 152 | 150 | 20.05.2026 | 160 mmø | 110
5043039 | 1600 | 152 | 150 | 20.05.2026 | 160 mmø | 110
5044333 | 29843.2 | 130 | 130 | 21.06.2026 | 110 mmø | -6193
5045290 | 10878.2 | 130 | 130 | 21.06.2026 | 110 mmø | -6193
5045316 | 296.784 | 130 | 130 | 21.06.2026 | 110 mmø | -6193
5045454 | 33322.4 | 130 | 130 | 21.06.2026 | 110 mmø | -6193
5045616 | 21551.4 | 130 | 130 | 21.06.2026 | 110 mmø | -6193
5045625 | 33429.5 | 130 | 130 | 21.06.2026 | 110 mmø | -6193

# IfcFlowSegment: Conduit with Fittings:OPI kanal, Conduit with Fittings:OPI kanal:4880158
In: Fjellhall Plan U
Type - PredefinedType: CONDUITSEGMENT
Classification: 4112 Installasjonskanaler med uttaksbokser (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Conduit with Fittings:OPI kanal; sets with these values: 2
Pset_FlowSegmentDuctSegment - Length: 763.421 mm; sets with these values: 2
NRVA - Fag: RIE; MMI_Kontrollert: OLSK; MMI_Utfort: CAH; MMI: 250; Delomrade: 130; Entreprise: E1; Omrade: 130; MMI_Godkjent: APH; MMI_Dato: 24.03.2026
RIE - V_Type: OPI kanal; V_Lengde: 763.421 mm; V_Dimensjon: 160 mmø; V_Referansenivå: Fjellhall Plan U; V_Installasjonshøyde: -502
